# Keil uVision project JAS208_V630_MG82F6D64.uvproj, settings and files
target Target 1 (MCS-51)
  device: MG82F6D64 Megawin
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0xEFF) CLOCK(25000000)
  output: JAS208_V630_MG82F6D64 +hex
  c flags: SizeSpeed=1
  c include: ../Common/General/;../Common/GPIO/;../Common/Interrupt/;../Common/RTC/;../Common/DMA/;../Include/;..\Common\Power
  group Source/App
    ../Source/: main.c interrupt.c System.c Utility.c
  group Source/Driver
    ../Source/: ADC_Driver.c I2C_Driver.c IAP_Driver.c IO_Driver.c RTC_Driver.c Timer_Driver.c UART_Driver.c
