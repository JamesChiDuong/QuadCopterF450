//============================================================================//
// User Includes
//============================================================================//
#include "CommFunc.h"

#include <math.h>
#include <stdlib.h>
#include <string.h>
#include <time.h>

#include "main.h"
#include "Default.h"


//============================================================================//
// User Variables
//============================================================================//

const char * const cWeekDay[] =
{ 
	"Sunday",
  "Monday",
	"Tuesday",
	"Wednesday",
	"Thursday",
	"Friday",
	"Saturday"
};

const char * const cMonth[] =
{ 
	"",
	"January",
  "February",
	"March",
	"April",
	"May",
	"June",
	"July",
	"August",
	"September",
	"October",
	"November",
	"December"
};

const uint8_t ASCII_WORD[] = {
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, //0
	0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xFC, 0x0D, 0xFC, 0x0D, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, //1
	0x00, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, //2 
	0x20, 0x02, 0xF8, 0x0F, 0xF8, 0x0F, 0x20, 0x02, 0xF8, 0x0F, 0xF8, 0x0F, 0x20, 0x02, 0x00, 0x00, //3 
	0x38, 0x03, 0x7C, 0x06, 0x44, 0x04, 0x47, 0x1C, 0x47, 0x1C, 0xCC, 0x07, 0x98, 0x03, 0x00, 0x00, //4
	0x30, 0x0C, 0x30, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x0C, 0x30, 0x0C, 0x00, 0x00, //5
	0x80, 0x07, 0xD8, 0x0F, 0x7C, 0x08, 0xE4, 0x08, 0xBC, 0x07, 0xD8, 0x0F, 0x40, 0x08, 0x00, 0x00, //6
	0x00, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, //7
	0x00, 0x00, 0x00, 0x00, 0xF0, 0x03, 0xF8, 0x07, 0x0C, 0x0C, 0x04, 0x08, 0x00, 0x00, 0x00, 0x00, //8
	0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0x0C, 0x0C, 0xF8, 0x07, 0xF0, 0x03, 0x00, 0x00, 0x00, 0x00, //9
	0x80, 0x00, 0xA0, 0x02, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xA0, 0x02, 0x80, 0x00, //10
	0x00, 0x00, 0x80, 0x00, 0x80, 0x00, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, //11
	0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, //12 
	0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, //13
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, //14
	0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x00, 0x00, //15
	0xF8, 0x07, 0xFC, 0x0F, 0x04, 0x09, 0xC4, 0x08, 0x24, 0x08, 0xFC, 0x0F, 0xF8, 0x07, 0x00, 0x00, //16
	0x00, 0x00, 0x10, 0x08, 0x18, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x00, 0x08, 0x00, 0x08, 0x00, 0x00, //17
	0x08, 0x0E, 0x0C, 0x0F, 0x84, 0x09, 0xC4, 0x08, 0x64, 0x08, 0x3C, 0x0C, 0x18, 0x0C, 0x00, 0x00, //18
	0x08, 0x04, 0x0C, 0x0C, 0x44, 0x08, 0x44, 0x08, 0x44, 0x08, 0xFC, 0x0F, 0xB8, 0x07, 0x00, 0x00, //19
	0xC0, 0x00, 0xE0, 0x00, 0xB0, 0x00, 0x98, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x80, 0x08, 0x00, 0x00, //20
	0x7C, 0x04, 0x7C, 0x0C, 0x44, 0x08, 0x44, 0x08, 0xC4, 0x08, 0xC4, 0x0F, 0x84, 0x07, 0x00, 0x00, //21
	0xF0, 0x07, 0xF8, 0x0F, 0x4C, 0x08, 0x44, 0x08, 0x44, 0x08, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x00, //22
	0x0C, 0x00, 0x0C, 0x00, 0x04, 0x0F, 0x84, 0x0F, 0xC4, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x00, 0x00, //23
	0xB8, 0x07, 0xFC, 0x0F, 0x44, 0x08, 0x44, 0x08, 0x44, 0x08, 0xFC, 0x0F, 0xB8, 0x07, 0x00, 0x00, //24
	0x38, 0x00, 0x7C, 0x08, 0x44, 0x08, 0x44, 0x08, 0x44, 0x0C, 0xFC, 0x07, 0xF8, 0x03, 0x00, 0x00, //25
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x06, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, //26
	0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x30, 0x0E, 0x30, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, //27
	0x00, 0x00, 0x80, 0x00, 0xC0, 0x01, 0x60, 0x03, 0x30, 0x06, 0x18, 0x0C, 0x08, 0x08, 0x00, 0x00, //28
	0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x40, 0x02, 0x00, 0x00, //29
	0x00, 0x00, 0x08, 0x08, 0x18, 0x0C, 0x30, 0x06, 0x60, 0x03, 0xC0, 0x01, 0x80, 0x00, 0x00, 0x00, //30
	0x18, 0x00, 0x1C, 0x00, 0x04, 0x00, 0xC4, 0x0D, 0xE4, 0x0D, 0x3C, 0x00, 0x18, 0x00, 0x00, 0x00, //31
	0xF0, 0x07, 0xF8, 0x0F, 0x08, 0x08, 0xC8, 0x0B, 0xC8, 0x0B, 0xF8, 0x0B, 0xF0, 0x01, 0x00, 0x00, //32
	0xE0, 0x0F, 0xF0, 0x0F, 0x98, 0x00, 0x8C, 0x00, 0x98, 0x00, 0xF0, 0x0F, 0xE0, 0x0F, 0x00, 0x00, //33
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x44, 0x08, 0x44, 0x08, 0xFC, 0x0F, 0xB8, 0x07, 0x00, 0x00, //34
	0xF0, 0x03, 0xF8, 0x07, 0x0C, 0x0C, 0x04, 0x08, 0x04, 0x08, 0x0C, 0x0C, 0x18, 0x06, 0x00, 0x00, //35
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x04, 0x08, 0x0C, 0x0C, 0xF8, 0x07, 0xF0, 0x03, 0x00, 0x00, //36
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x44, 0x08, 0xE4, 0x08, 0x0C, 0x0C, 0x1C, 0x0E, 0x00, 0x00, //37
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x44, 0x08, 0xE4, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x00, 0x00, //38
	0xF0, 0x03, 0xF8, 0x07, 0x0C, 0x0C, 0x84, 0x08, 0x84, 0x08, 0x8C, 0x07, 0x98, 0x0F, 0x00, 0x00, //39
	0xFC, 0x0F, 0xFC, 0x0F, 0x40, 0x00, 0x40, 0x00, 0x40, 0x00, 0xFC, 0x0F, 0xFC, 0x0F, 0x00, 0x00, //40
	0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x04, 0x08, 0x00, 0x00, 0x00, 0x00, //41
	0x00, 0x07, 0x00, 0x0F, 0x00, 0x08, 0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x07, 0x04, 0x00, 0x00, 0x00, //42
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0xC0, 0x00, 0xF0, 0x01, 0x3C, 0x0F, 0x0C, 0x0E, 0x00, 0x00, //43
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x04, 0x08, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x00, //44
	0xFC, 0x0F, 0xFC, 0x0F, 0x38, 0x00, 0x70, 0x00, 0x38, 0x00, 0xFC, 0x0F, 0xFC, 0x0F, 0x00, 0x00, //45
	0xFC, 0x0F, 0xFC, 0x0F, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFC, 0x0F, 0xFC, 0x0F, 0x00, 0x00, //46
	0xF0, 0x03, 0xF8, 0x07, 0x0C, 0x0C, 0x04, 0x08, 0x0C, 0x0C, 0xF8, 0x07, 0xF0, 0x03, 0x00, 0x00, //47
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x44, 0x08, 0x44, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x00, 0x00, //48
	0xF8, 0x07, 0xFC, 0x0F, 0x04, 0x08, 0x04, 0x0E, 0x04, 0x3C, 0xFC, 0x3F, 0xF8, 0x27, 0x00, 0x00, //49
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x44, 0x00, 0xC4, 0x00, 0xFC, 0x0F, 0x38, 0x0F, 0x00, 0x00, //50
	0x18, 0x06, 0x3C, 0x0E, 0x64, 0x08, 0x44, 0x08, 0xC4, 0x08, 0x9C, 0x0F, 0x18, 0x07, 0x00, 0x00, //51
	0x00, 0x00, 0x1C, 0x00, 0x0C, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x0C, 0x08, 0x1C, 0x00, 0x00, 0x00, //52
	0xFC, 0x07, 0xFC, 0x0F, 0x00, 0x08, 0x00, 0x08, 0x00, 0x08, 0xFC, 0x0F, 0xFC, 0x07, 0x00, 0x00, //53
	0xFC, 0x01, 0xFC, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x06, 0xFC, 0x03, 0xFC, 0x01, 0x00, 0x00, //54
	0xFC, 0x03, 0xFC, 0x0F, 0x00, 0x0E, 0x80, 0x03, 0x00, 0x0E, 0xFC, 0x0F, 0xFC, 0x03, 0x00, 0x00, //55
	0x0C, 0x0C, 0x3C, 0x0F, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x03, 0x3C, 0x0F, 0x0C, 0x0C, 0x00, 0x00, //56
	0x00, 0x00, 0x3C, 0x00, 0x7C, 0x08, 0xC0, 0x0F, 0xC0, 0x0F, 0x7C, 0x08, 0x3C, 0x00, 0x00, 0x00, //57
	0x1C, 0x0E, 0x0C, 0x0F, 0x84, 0x09, 0xC4, 0x08, 0x64, 0x08, 0x3C, 0x0C, 0x1C, 0x0E, 0x00, 0x00, //58
	0x00, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xFC, 0x0F, 0x04, 0x08, 0x04, 0x08, 0x00, 0x00, 0x00, 0x00, //59
	0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x00, //60
	0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x00, 0x00, 0x00, 0x00, //61
	0x08, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x00, 0x00, //62
	0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, 0x00, 0x20, //63
	0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x07, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, //64
	0x00, 0x07, 0xA0, 0x0F, 0xA0, 0x08, 0xA0, 0x08, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x08, 0x00, 0x00, //65
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x07, 0x20, 0x08, 0x60, 0x08, 0xC0, 0x0F, 0x80, 0x07, 0x00, 0x00, //66
	0xC0, 0x07, 0xE0, 0x0F, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0x60, 0x0C, 0x40, 0x04, 0x00, 0x00, //67
	0x80, 0x07, 0xC0, 0x0F, 0x60, 0x08, 0x24, 0x08, 0xFC, 0x07, 0xFC, 0x0F, 0x00, 0x08, 0x00, 0x00, //68
	0xC0, 0x07, 0xE0, 0x0F, 0xA0, 0x08, 0xA0, 0x08, 0xA0, 0x08, 0xE0, 0x0C, 0xC0, 0x04, 0x00, 0x00, //69
	0x40, 0x08, 0xF8, 0x0F, 0xFC, 0x0F, 0x44, 0x08, 0x0C, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, //70
	0xC0, 0x27, 0xE0, 0x6F, 0x20, 0x48, 0x20, 0x48, 0xC0, 0x7F, 0xE0, 0x3F, 0x20, 0x00, 0x00, 0x00, //71
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x40, 0x00, 0x20, 0x00, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x00, //72
	0x00, 0x00, 0x00, 0x00, 0x20, 0x08, 0xEC, 0x0F, 0xEC, 0x0F, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, //73
	0x00, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x40, 0x20, 0x40, 0xEC, 0x7F, 0xEC, 0x3F, 0x00, 0x00, //74
	0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x80, 0x01, 0xC0, 0x03, 0x60, 0x0E, 0x20, 0x0C, 0x00, 0x00, //75
	0x00, 0x00, 0x00, 0x00, 0x04, 0x08, 0xFC, 0x0F, 0xFC, 0x0F, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, //76
	0xE0, 0x0F, 0xE0, 0x0F, 0x60, 0x00, 0xC0, 0x0F, 0x60, 0x00, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x00, //77
	0x20, 0x00, 0xE0, 0x0F, 0xC0, 0x0F, 0x20, 0x00, 0x20, 0x00, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x00, //78
	0xC0, 0x07, 0xE0, 0x0F, 0x20, 0x08, 0x20, 0x08, 0x20, 0x08, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x00, //79
	0x20, 0x40, 0xE0, 0x7F, 0xC0, 0x7F, 0x20, 0x48, 0x20, 0x08, 0xE0, 0x0F, 0xC0, 0x07, 0x00, 0x00, //80
	0xC0, 0x07, 0xE0, 0x0F, 0x20, 0x08, 0x20, 0x48, 0xC0, 0x7F, 0xE0, 0x7F, 0x20, 0x40, 0x00, 0x00, //81
	0x20, 0x08, 0xE0, 0x0F, 0xC0, 0x0F, 0x60, 0x08, 0x20, 0x00, 0x60, 0x00, 0xC0, 0x00, 0x00, 0x00, //82
	0x40, 0x04, 0xE0, 0x0C, 0xA0, 0x09, 0x20, 0x09, 0x20, 0x0B, 0x60, 0x0E, 0x40, 0x04, 0x00, 0x00, //83
	0x20, 0x00, 0x20, 0x00, 0xF8, 0x07, 0xFC, 0x0F, 0x20, 0x08, 0x20, 0x0C, 0x00, 0x04, 0x00, 0x00, //84
	0xE0, 0x07, 0xE0, 0x0F, 0x00, 0x08, 0x00, 0x08, 0xE0, 0x07, 0xE0, 0x0F, 0x00, 0x08, 0x00, 0x00, //85
	0x00, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0x00, 0x0C, 0x00, 0x0C, 0xE0, 0x07, 0xE0, 0x03, 0x00, 0x00, //86
	0xE0, 0x07, 0xE0, 0x0F, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x0C, 0xE0, 0x0F, 0xE0, 0x07, 0x00, 0x00, //87
	0x20, 0x08, 0x60, 0x0C, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x60, 0x0C, 0x20, 0x08, 0x00, 0x00, //88
	0xE0, 0x47, 0xE0, 0x4F, 0x00, 0x48, 0x00, 0x48, 0x00, 0x68, 0xE0, 0x3F, 0xE0, 0x1F, 0x00, 0x00, //89
	0x60, 0x0C, 0x60, 0x0E, 0x20, 0x0B, 0xA0, 0x09, 0xE0, 0x08, 0x60, 0x0C, 0x20, 0x0C, 0x00, 0x00, //90
	0x00, 0x00, 0x40, 0x00, 0x40, 0x00, 0xF8, 0x07, 0xBC, 0x0F, 0x04, 0x08, 0x04, 0x08, 0x00, 0x00, //91
	0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xBC, 0x0F, 0xBC, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, //92
	0x00, 0x00, 0x04, 0x08, 0x04, 0x08, 0xBC, 0x0F, 0xF8, 0x07, 0x40, 0x00, 0x40, 0x00, 0x00, 0x00, //93
	0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x0C, 0x00, 0x08, 0x00, 0x0C, 0x00, 0x04, 0x00, 0x00, 0x00, //94
	0x00, 0x00, 0x00, 0x0C, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x0C  //95
};

const uint8_t TWord[4][32] = 
{
	{0xFF,0xFF,0xFF,0xFF,0xC0,0x00,0xC0,0x00,0xC0,0x00,0xC0,0x00,0xC0,0x00,0xC0,0x00,0xC0,0x00,0xC0,0x00,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0},
	{0xFF,0xFF,0xFF,0xFF,0x00,0x03,0x00,0x03,0x00,0x03,0x00,0x03,0x00,0x03,0x00,0x03,0x00,0x03,0x00,0x03,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF},
	{0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xF0,0xFF,0xFF,0xFF,0xFF},
	{0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0x0F,0xFF,0xFF,0xFF,0xFF,0xFF}
};

// Accumulated CRC value
//uint8_t u8CRC8_Value;
//uint16_t u16CRC16_Value;
//uint32_t u32CRC32_Value;


//============================================================================//
// User Functions
//============================================================================//

//============================================================================//
// @brief  Delay in microseconds.
// @param  u32_uSec: Number of microseconds to delay.
// @retval None.
//============================================================================//
void Delay_uS(const uint32_t u32_uSec)
{
	uint32_t u32Cnt = 0;
	const uint32_t u32Time = (120 * u32_uSec / 7);
	
	
	do
	{
	  if(++u32Cnt > u32Time)
		  return;
	}while (1);
}

//============================================================================//
// @brief  Convert a number in Binary format to BCD format.
// @param  u8BinVal: Number in Binary format.
// @retval BCD number in uint8_t format.
//============================================================================//
uint8_t Bin_2_BCD(uint8_t u8BinVal)
{
	uint8_t u8BCD_High = 0;
	
	
	while (u8BinVal >= 10) 
	{
		u8BCD_High++;
		
		u8BinVal -= 10;
	}
	
	return ((uint8_t)(u8BCD_High << 4) | u8BinVal);
}

//============================================================================//
// @brief  Convert a number in BCD format to Binary format.
// @param  u8BinVal: Number in BCD format.
// @retval Binary number in uint8_t format.
//============================================================================//
uint8_t BCD_2_Bin(uint8_t u8BCD_Val)
{
	uint8_t u8Temp = 0;
	
	
	u8Temp = ((uint8_t)(u8BCD_Val & (uint8_t)0xF0) >> (uint8_t)0x04) * 10;
	
	return (u8Temp + (u8BCD_Val & (uint8_t)0x0F));
}

//============================================================================//
// @brief  Convert the low part in a BCD byte to a ASCII character.
// @param  u8BCDByte: Number in BCD format.
// @retval Character in ASCII format.
//============================================================================//
uint8_t LowBCDToASCII(uint8_t u8BCDByte)
{
	uint8_t u8Buf;
	
	
	u8Buf = u8BCDByte & 0x0F;
	
	u8Buf |= 0x30;
	
	return u8Buf;
}

//============================================================================//
// @brief  Convert the high part in a BCD byte to a ASCII character.
// @param  u8BCDByte: Number in BCD format.
// @retval Character in ASCII format.
//============================================================================//
uint8_t HIGHBCDToASCII(uint8_t u8BCDByte)
{
	uint8_t u8Buf;
	
	
	u8Buf = (u8BCDByte >> 4);
	
	u8Buf &= 0x0F;
	
	u8Buf |= 0x30;
	
	return u8Buf;
}

//============================================================================//
// @brief  Convert the low part in a BCD byte to a decimal number.
// @param  u8BCDByte: Number in BCD format.
// @retval Character in ASCII format.
//============================================================================//
uint8_t LowBCDToNum(uint8_t u8BCDByte)
{
	uint8_t u8Buf;
	
	
	u8Buf = u8BCDByte & 0x0F;
	
	return u8Buf;
}

//============================================================================//
// @brief  Convert the high part in a BCD byte to a decimal number.
// @param  u8BCDByte: Number in BCD format.
// @retval Character in ASCII format.
//============================================================================//
uint8_t HIGHBCDToNum(uint8_t u8BCDByte)
{
	uint8_t u8Buf;
	
	
	u8Buf = (u8BCDByte >> 4);
	
	u8Buf &= 0x0F;
	
	return u8Buf;
}

//============================================================================//
// @brief  Convert a number in Binary format to BCD format ver 2.
// @param  u8BinVal: Number in Binary format.
// @retval BCD number in uint8_t format.
//============================================================================//
uint8_t Bin_2_BCD2(uint8_t u8BinValue)
{
	uint8_t u8BCDHigh = 0;
	
	
	while(u8BinValue >= 10) 
	{
		u8BCDHigh++;
		
		u8BinValue -= 10;
	}
	
	return ((uint8_t)(u8BCDHigh << 4) | u8BinValue);
}

//============================================================================//
// @brief  Convert a number in BCD format to Binary format ver 2.
// @param  u8BinVal: Number in BCD format.
// @retval Binary number in uint8_t format.
//============================================================================//
uint8_t BCD2_2_Bin(uint8_t u8BCDValue)
{
	uint8_t u8Temp = 0;
	
	
	u8Temp = ((uint8_t)(u8BCDValue & (uint8_t)0xF0) >> (uint8_t)0x04) * 10;
	
	return (u8Temp + (u8BCDValue & (uint8_t)0x0F));
}

//============================================================================//
// @brief  Set the first occurence of a character in a string to null character.
// @param  pcStr: Pointer to the string.
//         cEnd: Character to be changed. 
// @retval None.
//============================================================================//
void StopChar(char *pcStr, char cEnd)
{
	ChangeChar(pcStr, cEnd, '\0');
}

//============================================================================//
// @brief  Set the first occurence of a character in a string to 
//         another character.
// @param  pcStr: Pointer to the string.
//         cSource: Character to be changed. 
//         cTarget: Character for changing to. 
// @retval None.
//============================================================================//
void ChangeChar(char *pcStr, char cSource, char cTarget)
{
	uint8_t u8ChrCnt = 0;
	
	while(*(pcStr + u8ChrCnt))
	{
		if(*(pcStr + u8ChrCnt) == cSource)
		{
			*(pcStr + u8ChrCnt) = cTarget;
			
			return;
		}
		
		u8ChrCnt++;
	}
}

//============================================================================//
// @brief  Count the number of a character in a string.
// @param  pcStr: Pointer to the string.
//         cChar: Character to count. 
// @retval The number of character founded in format uint8_t.
//============================================================================//
uint8_t CountChar(char *pcStr, char cChar)
{
	uint8_t i = 0, CntCh = 0;
	
	
	while(*(pcStr + i))
	{
		if(*(pcStr + i) == cChar)
			CntCh++;
		
		i++;
	}
	
	return CntCh;
}

//============================================================================//
// @brief  Find the first occurrence of a character sequence in a string.
// @param  pcDat: Pointer to the string.
//         pcSeq: Pointer to the character sequence. 
//         pu16Pos: Pointer to the variable indicating the first occurence of 
//                  the character sequence. 
// @retval True: The character sequence exists in the string.
//         False: The character sequence does not exist in the string.
//============================================================================//
bool FindSequence(char *pcDat, char *pcSeq, uint16_t *pu16Pos)
{
  char *pcBuf;
	
	
	if(strlen(pcDat) < strlen(pcSeq))
		return FALSE;
	
	pcBuf = (char *)malloc(sizeof(char) * strlen(pcSeq));
	
	*pu16Pos = 0;
	
	// Compare data string at different positions to the characters sequence 
	while((*pu16Pos) != (strlen(pcDat) - strlen(pcSeq) + 1))
	{
	  memcpy(pcBuf, &(pcDat[*pu16Pos]), strlen(pcSeq));
		
		if(strncmp(pcBuf, pcSeq, strlen(pcSeq)) == 0)
    {
      free(pcBuf);
			
			pcBuf = NULL;
			
			return TRUE;
    }
		
		(*pu16Pos)++;
	}
	
	free(pcBuf);
	
	pcBuf = NULL;
	
	return FALSE;
}

//============================================================================//
// @brief  Set the current CRC8 value to an initial value.
// @param  *pu8CRC_Value: Pointer to the value that needs to be reset.
// @retval None.
//============================================================================//
void CRC8_Reset(uint8_t *pu8CRC_Value)
{
	*pu8CRC_Value = CRC8_RESET_VAL;
}

//============================================================================//
// @brief  Calculate and return a CRC8 value.
// @param  u8CRC8_Value: Current CRC8 value.
//         u8Dat: Data for calculating the new CRC8 value.
// @retval The updated CRC32 value in uint8_t format.
//============================================================================//
uint8_t CRC8_Calc(uint8_t u8CRC8_Value, uint8_t u8Dat)
{
	u8CRC8_Value += (uint16_t)u8Dat;

	return u8CRC8_Value;
}

//============================================================================//
// @brief  Set the current CRC16 value to an initial value.
// @param  pu16CRC16_Value: Pointer to the value that needs to be reset.
// @retval None.
//============================================================================//
void CRC16_Reset(uint16_t *pu16CRC16_Value)
{
	// Initial value 0 or 0xFFFF, CRC init. by CRC-CCITT
	*pu16CRC16_Value = CRC16_RESET_VAL;
}

//============================================================================//
// @brief  Calculate and update the current CRC16 value.
// @param  u16CRC16_Value: The current CRC16 value.
//         u8Dat: Data for calculating the new CRC32 value.
// @retval The updated CRC32 value in uint16_t format.
//============================================================================//
uint16_t CRC16_Calc(uint16_t u16CRC16_Value, uint8_t u8Dat)
{
	u16CRC16_Value += (uint16_t)u8Dat;

	return u16CRC16_Value;
}

//============================================================================//
// @brief  Set the current CRC32 value to an initial value.
// @param  pu32CRC32_Value: Pointer to the value that needs to be reset.
// @retval None.
//============================================================================//
void CRC32_Reset(uint32_t *pu32CRC32_Value)
{
	*pu32CRC32_Value = CRC32_RESET_VAL;
}

//============================================================================//
// @brief  Calculate and update the current CRC32 value.
//         u32CRC32_Value: The current CRC32 value.
// @param  u8Dat: Data for calculating the new CRC32 value.
// @retval The updated CRC32 value in uint32_t format.
//============================================================================//
uint32_t CRC32_Calc(uint32_t u32CRC32_Value, uint8_t u8Dat)
{
	CALC_CRC32(u32CRC32_Value, u8Dat);

	return u32CRC32_Value;
}

//============================================================================//
// @brief  Calculate checksum for a data array.
// @param  pu8Dat: Pointer to data array.
//         u32Datlen: Number of bytes to calculate checksum.
// @retval The updated CRC32 value in uint32_t format.
//============================================================================//
uint8_t CalCheckSum(uint8_t *pu8Dat, uint32_t u32DatLen)
{
	uint8_t u8CheckSum = 0;
	
	
  for(int i = 0; i < u32DatLen; i++)
	{
	  u8CheckSum ^= *pu8Dat;
		
		pu8Dat++;
	}
	
	return u8CheckSum;
}
