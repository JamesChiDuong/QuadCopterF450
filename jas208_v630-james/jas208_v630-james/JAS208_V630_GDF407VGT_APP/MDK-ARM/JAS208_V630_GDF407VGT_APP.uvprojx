# Keil uVision project JAS208_V630_GDF407VGT_APP.uvprojx, settings and files
target JAS208_V630_GDF407VGT_APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: JAS208_V630_GDF407VGT_APP +hex
  AfterMake: fromelf --bin ".\JAS208_V630_GDF407VGT_APP\@L.axf" --output ".\JAS208_V630_GDF407VGT_APP\@L.bin"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc; ../FATFS/Target; ../FATFS/App; ../Drivers/STM32F4xx_HAL_Driver/Inc; ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../Middlewares/Third_Party/FreeRTOS/Source/include; ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS; ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../Drivers/CMSIS/Include; ../Middlewares/GD/USB_Host_Library/Class/MSC/Inc; ../Middlewares/GD/USB_Host_Library/Core/Inc; ../Middlewares/GD/USB_Host_Library/Driver/Inc; ../Middlewares/GD/USB_Host_Library/USTD/Class/MSC; ../Middlewares/GD/USB_Host_Library/USTD/Common; ../Inc/PT_PRN
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x800c000 size 0xf4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: JAS208_V630_GDF407VGT_APP\JAS208_V630_GDF407VGT_APP.sct
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c freertos.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Application/User/Lib
    ../Core/Src/: Buzzer.c CAN_Driver.c CommFunc.c DataCollect.c DataLog.c DWT_Delay.c EXTIO.c GPS_Driver.c GSM_Driver.c GSM_QtEC21.c HW_Config.c LCD_Key.c LSM6DSL.c MC321x_Driver.c MG82_Driver.c MX25L_Driver.c PCF_Driver.c Power.c PRN_Driver.c Protocol.c RingBuf.c RuleV161.c RX8130_Driver.c SD_Module.c System.c UART_Driver.c UART_ExtDriver.c USB_Module.c USBH_Usr.c
    ../Core/Inc/: pt487fb_cm3.lib
  group Application/User/FATFS/Target
    ../FATFS/Target/: usbh_diskio.c bsp_driver_sd.c sd_diskio.c fatfs_platform.c user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_sd.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group USB_Core
    ../Middlewares/GD/USB_Host_Library/Core/Src/: usbh_core.c usbh_enum.c usbh_pipe.c usbh_transc.c
  group USB_Class
    ../Middlewares/GD/USB_Host_Library/Class/MSC/Src/: usbh_msc_bbb.c usbh_msc_core.c usbh_msc_scsi.c
  group USB_Driver
    ../Middlewares/GD/USB_Host_Library/Driver/Src/: drv_usb_core.c drv_usb_host.c drv_usb_hw.c drv_usbh_int.c
software components: CMSIS:CORE 5.6.0
